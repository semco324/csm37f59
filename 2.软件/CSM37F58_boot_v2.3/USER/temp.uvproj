# Keil uVision project temp.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: CSA37F60 Chipsea
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0EFFF) IROM2(0x00100000-0x00100FFF) XROM(0x00300000-0x003001FF) CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CSM37F58bootv23 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: ..\USER;..\37F60_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\hw_iic;..\HARDWARE\timer;..\HARDWARE\fmc
  library: MicroLIB
  memory RVCT1: ROM 0x300000 size 0x200
  memory RVCT4: ROM 0x0 size 0xf000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c csa37fx60_it.c system_csa37fx60.c boot.c
  group CORE
    ../CORE/: startup_CSA37FX60.s
  group 37F60_FWLIB
    ../37F60_FWLib/src/: csa37fx60_afe.c csa37fx60_crc32.c csa37fx60_fmc.c csa37fx60_gpio.c csa37fx60_hdiv.c csa37fx60_iic.c csa37fx60_nvic.c csa37fx60_pwr.c csa37fx60_rcc.c csa37fx60_system.c csa37fx60_systick.c csa37fx60_timer.c csa37fx60_uart.c csa37fx60_wdt.c csa37fx60_wdt_smart.c csa37fx60_wwdt.c
  group HARDWARE
    ../HARDWARE/hw_iic/: uiic.c
    ../HARDWARE/timer/: utimer.c
    ../HARDWARE/fmc/: ufmc.c
